LINUX-YOCTO_INC_AMD-VERSAL = ""
LINUX-YOCTO_INC_AMD-VERSAL:amd-versal = "linux-yocto-amd-versal.inc"
require ${LINUX-YOCTO_INC_AMD-VERSAL}

KBRANCH:amd-versal  = "v6.6/standard/sdkv6.6/xlnx-soc"
